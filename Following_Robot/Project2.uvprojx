# Keil uVision project Project2.uvprojx, settings and files
target Ultrasonic Range Finder (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SysTickPLL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PortF.c PortF.h PWM.c PWM.h Timer1.c Timer1.h PLL.c FollowingRobot.c FollowMe.c ADC1SS1.c ADC1SS1.h
software components: CMSIS:CORE 5.6.0
